# Keil uVision project timers.uvprojx, settings and files
target LPC4088 (ARM-ADS)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: timers
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M4
  asm define: CORE_M4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group src
    ./src/: main.c timer.c led.c
  group include
    ./src/: timer.h led.h
software components: CMSIS:CORE 4.2.0, Device:Startup 1.0.0
